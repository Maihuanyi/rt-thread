# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.4
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, __RTTHREAD__
  c include: ../../libcpu/arm/common;../../components/drivers/include;../../components/drivers/include;drivers;Libraries/MM32F526x/Include;../../components/libc/compilers/common/include;../../components/libc/posix/io/eventfd;Libraries/MM32F526x/HAL_Lib/Inc;.;../../components/drivers/include;../../components/libc/compilers/common/extension/fcntl/octal;../../libcpu/arm/cortex-m33;../../include;../../components/libc/posix/ipc;applications;../../components/drivers/include;../../components/libc/posix/io/poll;Libraries/MM32F526x/Source;Libraries/CMSIS/KEIL_Core;../../components/drivers/smp_call;../../components/drivers/phy;../../components/libc/compilers/common/extension;../../components/drivers/include;../../components/libc/posix/io/epoll;../../components/finsh
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\drivers\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    Libraries/MM32F526x/Source/KEIL_StartAsm/: startup_mm32f5260_keil.c
    drivers/: drv_uart.c board.c drv_gpio.c
  group Finsh
    ../../components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../src/klibc/: kstdio.c rt_vsscanf.c kstring.c kerrno.c rt_vsnprintf_tiny.c
  group libcpu
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    Libraries/MM32F526x/HAL_Lib/Src/: hal_dma.c hal_rtc.c hal_i2c.c hal_syscfg.c hal_lptim.c hal_wwdg.c hal_bkp.c hal_gpio.c hal_uid.c hal_flexcan.c hal_rcc.c hal_exti.c hal_qspi.c hal_comp.c hal_lpuart.c hal_spi.c hal_crcpoly.c hal_fsmc.c hal_cordic.c hal_enet.c hal_flash.c hal_crs.c hal_misc.c hal_adc.c hal_dbg.c hal_tim.c hal_pwr.c hal_dac.c hal_usbfs.c hal_uart.c hal_iwdg.c hal_mds.c
    build/Libraries/MM32F526x/Source/KEIL_StartAsm/: startup_mm32f526x_keil.s
    Libraries/MM32F526x/Source/: system_mm32f526x.c
