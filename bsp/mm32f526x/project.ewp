# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../libcpu/arm/cortex-m33; ../../components/libc/compilers/common/extension/fcntl/octal; Libraries/CMSIS/KEIL_Core; ../../components/drivers/smp_call; Libraries/MM32F526x/Source; applications; Libraries/MM32F526x/Include; ../../components/drivers/phy; drivers; ../../components/finsh; ../../libcpu/arm/common; ../../components/libc/posix/io/eventfd; ../../components/drivers/include; Libraries/MM32F526x/HAL_Lib/Inc; ../../components/libc/compilers/common/include; ../../components/libc/posix/io/epoll; .; ../../include; ../../components/libc/posix/ipc; ../../components/libc/posix/io/poll; ../../components/libc/compilers/common/extension
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: drv_uart.c drv_gpio.c board.c
    Libraries/MM32F526x/Source/IAR_StartAsm/: startup_mm32f5260_iar.s
  group Finsh
    ../../components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../src/klibc/: kstring.c kstdio.c rt_vsnprintf_tiny.c kerrno.c rt_vsscanf.c
  group libcpu
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group Libraries
    Libraries/MM32F526x/HAL_Lib/Src/: hal_dma.c hal_rtc.c hal_i2c.c hal_syscfg.c hal_lptim.c hal_wwdg.c hal_bkp.c hal_gpio.c hal_flexcan.c hal_rcc.c hal_exti.c hal_qspi.c hal_comp.c hal_lpuart.c hal_spi.c hal_crcpoly.c hal_fsmc.c hal_cordic.c hal_enet.c hal_flash.c hal_uid.c hal_crs.c hal_misc.c hal_adc.c hal_dbg.c hal_tim.c hal_pwr.c hal_dac.c hal_usbfs.c hal_uart.c hal_iwdg.c hal_mds.c
    build/Libraries/MM32F526x/Source/IAR_StartAsm/: startup_mm32f526x_iar.s
    Libraries/MM32F526x/Source/: system_mm32f526x.c
